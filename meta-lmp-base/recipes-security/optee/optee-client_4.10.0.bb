require optee-client-fio.inc

SRCREV = "074f9cbb08d80257ce90a62ad9e8a29b50c7f96b"

SRC_URI += " \
	file://0001-FIO-extras-pkcs11-change-UUID-to-avoid-conflict-with.patch \
"
